#Adjust these as needed
WOLFSSL_VERSION ?= ""

WOLFSSL_SRC ?= "wolfssl-${WOLFSSL_VERSION}-gplv3-fips-ready"
WOLFSSL_SRC_SHA ?= ""

FIPS_HASH ?= "FFBB0434EB0EF2860CBAF6CB29F8F39B4432439EFD2A24C7D6442CBA8E06A4CC"
LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"
#Do not adjust these variables
PR = "fipsReady"
PV = "${WOLFSSL_VERSION}"

BBFILE_PRIORITY='1'
