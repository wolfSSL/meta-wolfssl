FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://tcpdump-4.9.3.patch"
PACKAGECONFIG_remove = "openssl"
DEPENDS += "virtual/wolfssl"
EXTRA_OECONF += "--with-wolfssl=${STAGING_EXECPREFIXDIR}"
