EXTRA_OECONF += "--enable-strongswan"
