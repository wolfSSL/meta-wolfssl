EXTRA_OECONF += "--enable-curl"
