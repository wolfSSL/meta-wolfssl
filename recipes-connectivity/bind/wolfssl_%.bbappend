EXTRA_OECONF += "--enable-bind"
