EXTRA_OECONF += "--enable-maxfragment --enable-opensslall --enable-opensslextra --enable-dtls"

