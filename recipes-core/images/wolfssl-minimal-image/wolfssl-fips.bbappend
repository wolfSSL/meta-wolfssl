# Manual configuration for wolfssl-image-minimal
# Enable features needed for test and benchmark utilities

require ${WOLFSSL_LAYERDIR}/inc/wolfcryptbenchmark/wolfssl-enable-wolfcryptbenchmark.inc
require ${WOLFSSL_LAYERDIR}/inc/wolfcrypttest/wolfssl-enable-wolfcrypttest.inc

