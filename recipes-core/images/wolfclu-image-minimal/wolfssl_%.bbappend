# Manual configuration for wolfclu-image-minimal
# Enable wolfCLU support in wolfSSL

require ${WOLFSSL_LAYERDIR}/inc/wolfclu/wolfssl-enable-wolfclu.inc

