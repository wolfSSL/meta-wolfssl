# Configure wolfssl for gnutls-nonfips-image-minimal
require ${WOLFSSL_LAYERDIR}/inc/wolfssl/wolfssl-enable-gnutls.inc
