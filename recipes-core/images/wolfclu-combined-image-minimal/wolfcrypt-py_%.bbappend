# Disable feature check for wolfcrypt-py in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

