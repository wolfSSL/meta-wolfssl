# Disable feature check for wolfssl-py in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

