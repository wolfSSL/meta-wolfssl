# Disable feature check for wolf-py-tests in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

