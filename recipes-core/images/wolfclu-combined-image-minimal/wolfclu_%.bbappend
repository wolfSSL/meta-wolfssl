# Disable feature check for wolfclu in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

