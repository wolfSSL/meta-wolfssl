# Manual configuration for wolftpm-image-minimal
# Enable wolfTPM support in wolfSSL

require ${WOLFSSL_LAYERDIR}/inc/wolftpm/wolfssl-enable-wolftpm.inc

