# Disable feature check for wolfmqtt in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

