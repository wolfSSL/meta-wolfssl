# Configure OpenSSL for wolfProvider in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfprovider/openssl/openssl-enable-wolfprovider.inc

