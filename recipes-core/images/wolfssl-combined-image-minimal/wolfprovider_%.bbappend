# Disable feature check for wolfprovider in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

