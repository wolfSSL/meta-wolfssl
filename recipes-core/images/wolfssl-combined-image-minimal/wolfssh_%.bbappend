# Disable feature check for wolfssh in combined image
require ${WOLFSSL_LAYERDIR}/inc/wolfssl-manual-config.inc

