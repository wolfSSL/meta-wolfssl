require ${WOLFSSL_LAYERDIR}/inc/${LAYERSERIES_CORENAMES}/libssh/libssh-enable-libgcrypt-wolfssl.inc
