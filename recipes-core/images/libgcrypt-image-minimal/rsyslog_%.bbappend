require ${WOLFSSL_LAYERDIR}/inc/${LAYERSERIES_CORENAMES}/rsyslog/rsyslog-enable-fips-crypto.inc

