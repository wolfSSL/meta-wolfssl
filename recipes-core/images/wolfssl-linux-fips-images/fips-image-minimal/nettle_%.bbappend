# Configure nettle for gnutls.
# nettle 3.10 in order to correctly build
# the latest release of gnutls.
#

require ${WOLFSSL_LAYERDIR}/inc/nettle/nettle.inc
