# Conditionally configure curl with wolfProvider support

require ${WOLFSSL_LAYERDIR}/inc/wolfprovider/curl/curl-enable-wolfprovider.inc
