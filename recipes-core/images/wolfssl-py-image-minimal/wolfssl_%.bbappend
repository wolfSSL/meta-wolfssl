# Manual configuration for wolfssl-py-image-minimal
# Enable wolfSSL features for Python bindings (wolfssl-py and wolfcrypt-py) and tests

require ${WOLFSSL_LAYERDIR}/inc/wolfssl-py/wolfssl-enable-wolfssl-py.inc
require ${WOLFSSL_LAYERDIR}/inc/wolfcrypt-py/wolfssl-enable-wolfcrypt-py.inc
require ${WOLFSSL_LAYERDIR}/inc/wolf-py-tests/wolfssl-enable-wolf-py-tests.inc

