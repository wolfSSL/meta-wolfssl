require ${WOLFSSL_LAYERDIR}/inc/${LAYERSERIES_CORENAMES}/librelp/librelp-ptest.inc
