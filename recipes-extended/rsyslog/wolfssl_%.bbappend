EXTRA_OECONF += "--enable-rsyslog"
